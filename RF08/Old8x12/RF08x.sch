# EAGLE board RF08x (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
DMA11  (via drill 0.61) (continued)
  Bottom 0.254: 127,78.57 v127.63,78.57 | 127,78.57 125.73,78.57 DMA8-11.3 | v132.71,92.54 v153.66,92.54 | 127,78.57 127,74.77 122.55,74.77 120.65,72.86 113.03,72.86 112.39,73.49 106.04,73.49 v105.41,72.86 | v103.5,67.78 102.87,67.14 74.93,67.14 70.48,71.59 v69.21,71.59 | v68.58,74.13 57.78,74.13 56.51,75.4 IC23.12
DMA-IN\  (via drill 0.61)
  Top 0.254: 17.14,44.92 15.87,43.65 IC34.1 | 17.14,64.6 17.14,71.59 15.87,72.86 IC26.1 | 17.14,44.92 17.14,64.6 | 17.14,64.6 20.95,68.41 20.95,69.05 22.22,70.32 IC26.19 23.49,71.59 24.76,72.86 24.76,93.18 v25.39,93.81 | v20.32,20.16 17.14,23.33 17.14,44.92
  Bottom 0.254: v20.32,20.16 25.39,15.08 76.2,15.08 76.83,15.71 83.18,15.71 85.72,13.17 IC41.12 | v25.39,93.81 33.02,93.81 37.46,98.26 IC13.4
DMA-OUT\
  Top 0.254: 68.58,37.94 70.48,39.84 IC35.1 | 68.58,37.94 67.94,37.3 67.94,34.12 67.31,33.49 67.31,18.89 70.48,15.71 70.48,3.01 76.83,3.01 77.47,3.65 77.47,6.18 78.1,6.82 81.91,6.82 82.55,6.18 82.55,3.01 92.07,3.01 92.7,3.65 92.7,10 93.98,11.27 IC41.9 | 68.58,37.94 68.58,65.88 70.48,67.78 IC28.1
  Bottom 0.254: IC28.1 72.39,68.41 74.93,65.88 77.47,65.88 IC28.19 | IC35.19 77.47,37.94 76.83,38.57 74.29,38.57 72.39,40.48 IC35.1
DONE  (via drill 0.61)
  Top 0.254: v144.78,7.46 144.78,12.54 140.33,16.98 IC40.2
  Bottom 0.254: v144.78,7.46 146.05,6.18 161.92,6.18 162.56,5.55 191.13,5.55 194.31,8.73 196.84,8.73 201.93,13.81 201.93,120.48 176.53,120.48 175.89,119.85 174.62,119.85 173.35,121.12 IC11.9
DRV01\  (via drill 0.61)
  Top 0.254: IC23.22 53.34,90 53.34,83.02 54.6,81.75 54.6,74.77 53.97,74.13 53.97,70.32 53.34,69.68 IC27.22 53.34,67.14 v53.34,63.97 | v81.28,37.94 81.28,19.52 82.55,18.25 82.55,7.46 83.81,6.18 IC41.4 | v12.06,45.55 11.42,46.19 11.42,65.24 v12.06,65.88
  Bottom 0.254: v81.28,37.94 80.01,39.2 74.93,39.2 71.75,42.38 26.03,42.38 22.86,45.55 v12.06,45.55 | v12.06,65.88 12.69,66.51 13.33,66.51 13.96,67.14 19.05,67.14 21.59,64.6 52.7,64.6 v53.34,63.97
DRV23\  (via drill 0.61)
  Top 0.254: IC33.22 53.34,44.29 53.34,32.86 54.6,31.59 54.6,29.05 53.97,28.41 53.97,24.6 53.34,23.96 IC39.22 53.34,21.43 53.34,10.63 v54.6,9.36 | v87.62,10.63 87.62,10 91.44,6.18 IC41.7
  Bottom 0.254: v87.62,10.63 86.99,10 55.24,10 v54.6,9.36
EIE
  Top 0.254: IC37.2 187.32,27.14 184.15,23.96 184.15,8.73 178.43,3.01 173.35,3.01 173.35,4.28 177.8,8.73 INTENB.6
  Bottom 0.254: IC40.9 148.59,7.46 149.86,8.73 163.83,8.73 164.46,8.09 173.35,8.09 173.99,8.73 173.99,11.9 175.89,11.9 177.16,10.63 INTENB.6
ERROR  (via drill 0.61)
  Top 0.254: v145.41,26.51 145.41,11.9 146.68,10.63 IC40.10 | v159.38,30.32 162.56,33.49 162.56,51.27 163.19,51.91 163.19,77.94 162.56,78.57 162.56,101.43 163.83,102.7 v163.83,103.34 163.83,135.72 163.19,136.36 161.28,136.36 161.28,130.01 160.02,128.74 160.02,128.11 IC7.2
  Bottom 0.254: v145.41,26.51 149.22,30.32 v159.38,30.32 | v163.83,103.34 184.78,103.34 186.69,101.43 IC12.6
EXAD0\  (via drill 0.61)
  Top 0.254: v7.62,83.02 6.34,81.75 6.34,67.78 7.62,66.51 C35L.34
  Bottom 0.254: v7.62,83.02 13.33,83.02 13.96,83.65 IC20.9
EXAD1\
  Bottom 0.254: IC20.7 13.96,88.73 9.52,84.29 7.62,84.29 2.54,79.21 2.54,69.05 7.62,69.05 C35L.36
EXAD2\
  Top 0.254: IC20.5 14.6,93.18 9.52,88.1 9.52,74.77 8.88,74.13 8.88,72.86 7.62,71.59 C35L.38
F.1  (via drill 0.61)
  Top 0.254: v68.58,83.65 69.21,84.29 v69.21,88.1
  Bottom 0.254: v68.58,83.65 67.94,84.29 51.43,84.29 50.16,83.02 26.03,83.02 24.12,81.11 IC20.11 | v69.21,88.1 78.1,88.1 80.01,90 80.01,93.81 126.36,93.81 127.63,95.08 166.37,95.08 167,95.72 191.13,95.72 199.38,87.46 199.38,82.38 | 199.38,82.38 190.5,82.38 189.22,83.65 FIELD.3 | 199.38,82.38 201.29,82.38 201.29,48.73 196.84,44.29 190.5,44.29 189.22,43.02 IC30.8
F.2  (via drill 0.61)
  Top 0.254: v198.75,37.94 198.12,38.57 v198.12,83.65
  Bottom 0.254: IC20.13 24.12,86.19 149.86,86.19 151.12,87.46 161.28,87.46 162.56,86.19 186.69,86.19 FIELD.2 189.22,86.19 190.5,84.92 196.84,84.92 v198.12,83.65 | v198.75,37.94 196.84,37.94 IC30.11
F.3  (via drill 0.61)
  Top 0.254: v191.77,76.03 192.4,75.4 192.4,49.37 191.13,48.09 v191.13,43.02 v191.13,16.35 | v84.45,117.31 85.09,116.67 85.09,110.32 88.9,106.52 v88.9,95.08 | v91.44,95.08 92.7,93.81 92.7,87.46 90.17,84.92 90.17,62.06 88.9,60.8 v88.9,58.26 | v101.59,53.18 100.33,51.91 100.33,41.74 102.87,39.2 v102.87,36.03 | v111.76,34.12 113.03,32.86 113.03,22.06 111.76,20.79 v111.76,6.18 | v109.22,6.18 109.22,3.01 110.48,1.74 171.44,1.74 v171.44,15.08
  Bottom 0.254: v191.77,76.03 189.22,76.03 FIELD.6 | v191.13,43.02 194.31,43.02 IC30.13 | v84.45,117.31 36.19,117.31 31.11,112.23 6.34,112.23 6.34,102.7 13.96,95.08 17.78,95.08 21.59,91.27 IC20.15 | v91.44,95.08 v88.9,95.08 | v88.9,58.26 93.98,53.18 v101.59,53.18 | v102.87,36.03 104.77,34.12 v111.76,34.12 | v109.22,6.18 v111.76,6.18 | v171.44,15.08 172.08,15.71 186.05,15.71 186.69,16.35 v191.13,16.35
GND  (via drill 0.61)
  Top 0.508: v66.04,17.62 66.04,8.73 IC39.16 | v66.04,25.23 66.04,29.05 IC33.16 | v68.58,22.7 67.94,22.06 67.94,20.79 70.48,18.25 IC35.10 71.75,18.25 74.93,21.43 v74.93,22.7 | v97.15,5.55 99.06,7.46 99.06,18.89 IC36.4 | 80.64,25.87 80.64,24.6 79.37,23.33 IC35.13 | 80.64,25.87 79.37,27.14 IC35.15 | 80.64,25.87 80.64,30.95 79.37,32.22 IC35.17 | D35L.1 86.36,20.79 86.36,22.06 D35L.3 86.36,23.33 86.36,24.6 D35L.5 86.36,25.87 86.36,27.14 D35L.7 86.36,28.41 86.36,29.68 D35L.9 86.36,30.95 86.36,32.22 D35L.11 86.36,33.49 86.36,34.76 D35L.13 86.36,36.03 86.36,37.3 D35L.15 86.36,38.57 86.36,39.84 D35L.17 86.36,41.11 86.36,42.38 D35L.19 86.36,43.65 86.36,44.92 D35L.21 86.36,46.19 86.36,47.46 D35L.23 86.36,48.73 86.36,50 D35L.25 86.36,51.27 86.36,52.54 D35L.27 86.36,53.81 86.36,55.08 D35L.29 86.36,56.35 86.36,57.62 D35L.31 86.36,58.89 86.36,60.16 D35L.33 86.36,61.43 86.36,62.7 D35L.35 86.36,63.97 86.36,65.24 D35L.37 86.36,66.51 86.36,67.78 D35L.39 86.36,69.05 v86.36,79.21 | DMA0-3.8 125.09,5.55 126.36,6.82 126.36,13.17 125.09,14.44 DMA0-3.4 125.09,15.71 127.63,18.25 127.63,25.87 125.09,28.41 125.09,34.76 DMA4-7.8 | IC38.10 153.66,4.92 158.75,4.92 IC38.11 160.65,5.55 161.92,6.82 161.92,8.09 160.65,9.36 IC38.13 159.38,10.63 158.11,11.9 158.11,13.17 | 158.11,13.17 159.38,14.44 IC38.15 | 158.11,13.17 158.11,18.25 159.38,19.52 IC38.17 | IC22.7 114.3,82.38 114.93,81.75 114.93,77.3 v116.84,75.4 116.84,69.05 D36L.39 116.84,67.78 116.84,66.51 D36L.37 116.84,65.24 116.84,63.97 D36L.35 116.84,62.7 116.84,61.43 D36L.33 116.84,60.16 116.84,58.89 D36L.31 116.84,57.62 116.84,56.35 D36L.29 116.84,55.08 116.84,53.81 D36L.27 116.84,52.54 116.84,51.27 D36L.25 116.84,50 116.84,48.73 D36L.23 116.84,47.46 116.84,46.19 D36L.21 116.84,44.92 116.84,43.65 D36L.19 116.84,42.38 116.84,41.11 D36L.17 116.84,39.84 116.84,38.57 D36L.15 116.84,37.3 116.84,36.03 D36L.13 116.84,34.76 116.84,33.49 D36L.11 116.84,32.22 116.84,30.95 D36L.9 116.84,29.68 116.84,28.41 D36L.7 116.84,27.14 116.84,25.87 D36L.5 116.84,24.6 116.84,23.33 D36L.3 116.84,22.06 116.84,20.79 D36L.1
  Top 0.508: DAR8-11.8 140.33,66.51 141.6,67.78 141.6,74.13 140.33,75.4 DAR8-11.4 | DAR4-7.8 140.33,36.03 141.6,37.3 141.6,43.65 140.33,44.92 DAR4-7.4 | 31.75,98.26 31.11,98.26 IC13.1 | 31.75,98.26 32.38,98.26 IC13.2 | 31.75,98.26 v31.75,126.2 | IC14.13 53.34,105.24 53.34,100.16 IC14.2 | IC2.8 53.34,125.56 54.6,124.29 54.6,112.86 49.52,107.78 49.52,102.07 50.79,100.8 50.79,100.16 IC14.1 | IC34.10 13.96,20.16 10.15,23.96 10.15,24.6 C35L.1 10.15,25.87 10.15,27.14 C35L.3 10.15,28.41 10.15,29.68 C35L.5 10.15,30.95 10.15,32.22 C35L.7 10.15,33.49 10.15,34.76 C35L.9 10.15,36.03 10.15,37.3 C35L.11 10.15,38.57 10.15,39.84 C35L.13 10.15,41.11 10.15,42.38 C35L.15 10.15,43.65 10.15,44.92 C35L.17 10.15,46.19 10.15,47.46 C35L.19 10.15,48.73 10.15,50 C35L.21 10.15,51.27 10.15,52.54 C35L.23 10.15,53.81 10.15,55.08 C35L.25 10.15,56.35 10.15,57.62 C35L.27 10.15,58.89 10.15,60.16 C35L.29 10.15,61.43 10.15,62.7 C35L.31 10.15,63.97 10.15,65.24 C35L.33 10.15,66.51 10.15,67.78 C35L.35 10.15,69.05 10.15,70.32 C35L.37 10.15,71.59 10.15,72.86 C35L.39 10.15,74.13 10.15,76.03 14.6,80.48 IC20.10 15.87,81.75 17.14,83.02 17.14,91.91 21.59,96.35 IC20.17 | IC21.8 91.44,84.92 93.98,87.46 93.98,97.62 IC16.1 93.98,100.16 93.98,102.7 96.52,105.24 IC16.15 | IC23.16 66.04,77.3 66.67,77.94 66.67,89.37 67.31,90 67.31,96.35 66.04,97.62 IC14.7 66.04,100.16 v66.04,102.07 | IC3.7 76.83,126.2 78.1,126.2 IC3.8 78.73,125.56 80.01,124.29 80.01,117.94 77.47,115.4 77.47,110.32 80.01,107.78 80.01,105.24 78.73,103.97 78.73,100.16 IC15.4 | IC7.1 157.47,128.11 160.02,130.65 160.02,133.19 IC7.15
  Top 0.508: 148.59,124.93 149.22,124.93 149.22,126.2 IC6.8 | 148.59,124.93 142.87,124.93 140.33,122.39 IC10.12 | 148.59,124.93 148.59,116.67 149.86,115.4 IC10.7 | IC17.8 137.79,99.53 138.43,100.16 138.43,111.59 137.16,112.86 IC10.2 | IC9.12 114.3,120.48 114.3,117.94 111.76,115.4 IC9.2 111.76,112.86 111.76,109.05 113.03,107.78 113.03,102.07 111.76,100.8 111.76,100.16 IC16.8 | IC17.1 119.38,100.16 119.38,102.7 121.92,105.24 IC17.15 121.92,107.78 124.45,110.32 124.45,112.86 IC9.7 124.45,115.4 124.45,117.31 125.73,118.58 125.73,124.29 124.45,125.56 IC5.7 124.45,128.11 124.45,131.28 123.19,132.55 123.19,136.36 108.58,136.36 107.95,135.72 107.95,128.74 v106.68,127.47 | IC8.1 187.96,132.55 187.96,133.82 C1.2 | IC7.8 175.25,125.56 176.53,124.29 176.53,116.67 175.25,115.4 IC11.7 175.25,112.86 186.05,102.07 186.05,96.99 | 186.05,96.99 187.32,98.26 IC12.7 | 186.05,96.99 183.51,94.45 IC19.7 182.88,92.54 182.88,81.11 186.69,81.11 FIELD.4 187.32,80.48 187.32,79.21 FIELD.5 187.32,77.94 186.05,76.67 186.05,72.86 187.32,71.59 FIELD.8 | J14.2 172.08,22.7 170.81,22.7 D34L.1 170.18,23.33 170.18,24.6 D34L.3 170.18,25.87 170.18,27.14 D34L.5 170.18,28.41 170.18,29.68 D34L.7 170.18,30.95 170.18,32.22 D34L.9 170.18,33.49 170.18,34.76 D34L.11 170.18,36.03 170.18,37.3 D34L.13 170.18,38.57 170.18,39.84 D34L.15 170.18,41.11 170.18,42.38 D34L.17 170.18,43.65 170.18,44.92 D34L.19 170.18,46.19 170.18,47.46 D34L.21 170.18,48.73 170.18,50 D34L.23 170.18,51.27 170.18,52.54 D34L.25 170.18,53.81 170.18,55.08 D34L.27 170.18,56.35 170.18,57.62 D34L.29 170.18,58.89 170.18,60.16 D34L.31 170.18,61.43 170.18,62.7 D34L.33 170.18,63.97 170.18,65.24 D34L.35 170.18,66.51 170.18,67.78 D34L.37 170.18,69.05 170.18,70.32 D34L.39
  Top 0.508: J14.2 172.72,23.33 172.72,24.6 J13.2 172.72,25.87 172.72,27.14 J12.2 172.72,28.41 172.72,29.68 J11.2 172.72,30.95 172.72,32.22 J10.2 172.72,33.49 172.72,34.76 J9.2 172.72,36.03 172.72,37.3 J8.2 | 173.99,9.36 174.62,9.36 INTENB.5 | 173.99,9.36 173.35,9.36 INTENB.4 | INTENB.8 182.88,11.27 182.88,16.35 INTENB.9 182.88,18.89 182.88,22.06 C36L.1 182.88,23.33 182.88,24.6 C36L.3 182.88,25.87 182.88,27.14 C36L.5 182.88,28.41 182.88,29.68 C36L.7 182.88,30.95 182.88,32.22 C36L.9 182.88,33.49 182.88,34.76 C36L.11 182.88,36.03 182.88,37.3 C36L.13 182.88,38.57 182.88,39.84 C36L.15 182.88,41.11 182.88,42.38 C36L.17 182.88,43.65 182.88,44.92 C36L.19 182.88,46.19 182.88,47.46 C36L.21 182.88,48.73 182.88,50 C36L.23 182.88,51.27 182.88,52.54 C36L.25 182.88,53.81 182.88,55.08 C36L.27 182.88,56.35 182.88,57.62 C36L.29 182.88,58.89 182.88,60.16 C36L.31 182.88,61.43 182.88,62.7 C36L.33 182.88,63.97 182.88,65.24 C36L.35 182.88,66.51 182.88,67.78 C36L.37 182.88,69.05 182.88,70.32 C36L.39 | 173.99,9.36 173.99,20.79 172.72,22.06 J14.2
  Bottom 0.508: D35L.33 86.99,60.8 99.06,60.8 100.96,62.7 IC25.5 102.23,63.97 103.5,65.24 107.31,65.24 108.58,63.97 IC25.8 | v66.04,17.62 69.84,17.62 IC35.10 | v68.58,22.7 v66.04,25.23 | v97.15,5.55 94.61,5.55 IC41.8 | 73.02,46.83 73.02,46.19 71.75,46.19 IC28.10 | 73.02,46.83 73.02,48.73 72.39,49.37 69.84,49.37 66.67,52.54 IC27.16 | IC35.17 80.01,32.86 81.28,34.12 84.45,34.12 85.72,32.86 D35L.11 | 73.02,46.83 84.45,46.83 85.72,48.09 D35L.23 | D35L.3 86.99,22.7 96.52,22.7 98.42,20.79 IC36.4 99.69,19.52 100.96,19.52 IC36.5 102.23,20.79 103.5,22.06 107.31,22.06 108.58,20.79 IC36.8 109.85,19.52 110.48,18.89 114.93,18.89 116.2,20.16 D36L.1 | v74.93,22.7 77.47,22.7 IC35.13 | 142.24,3.65 140.97,4.92 IC40.7 | 142.24,3.65 149.86,3.65 151.12,4.92 IC38.10 | 142.24,3.65 127,3.65 125.73,4.92 DMA0-3.8 | v116.84,75.4 122.55,75.4 123.19,76.03 DMA8-11.4 | IC24.10 151.12,65.88 149.86,64.6 142.24,64.6 140.97,65.88 DAR8-11.8 138.43,65.88 137.16,64.6 127,64.6 125.73,65.88 DMA8-11.8 123.19,65.88 117.47,65.88 D36L.37 | IC31.10 151.12,35.4 149.86,34.12 145.41,34.12 144.14,35.4 140.97,35.4 DAR4-7.8 | 105.41,39.84 107.31,39.84 108.58,38.57 IC32.8 109.85,37.3 110.48,36.66 114.93,36.66 116.2,37.94 D36L.15 | 105.41,39.84 103.5,39.84 102.23,38.57 IC32.5 | 105.41,48.73 107.31,48.73 108.58,50 IC29.8 | 105.41,48.73 103.5,48.73 102.23,50 IC29.5 | 105.41,39.84 105.41,48.73 | DMA4-7.8 123.19,35.4 117.47,35.4 D36L.13 | D36L.21 117.47,45.55 123.19,45.55 DMA4-7.4 125.73,45.55 127,44.29 137.16,44.29 138.43,45.55 DAR4-7.4 | IC1.7 26.03,126.2 27.3,126.2 IC1.8 28.57,126.2 v31.75,126.2 | IC20.17 24.12,96.35 26.03,98.26 29.84,98.26 IC13.1
  Bottom 0.508: IC2.7 51.43,126.2 52.7,126.2 IC2.8 | IC13.2 33.65,99.53 34.92,100.8 43.81,100.8 45.08,99.53 IC13.7 46.35,98.26 50.16,98.26 IC14.1 51.43,98.26 52.7,98.26 IC14.2 53.97,98.26 55.24,96.99 56.51,96.99 57.78,98.26 IC14.4 58.41,100.16 60.32,102.07 v66.04,102.07 | IC26.10 13.96,50.63 10.79,50.63 C35L.21 | J2.2 5.71,53.18 6.98,54.45 8.25,54.45 9.52,55.72 C35L.25 10.79,55.72 12.06,55.72 J1.2 | 80.64,96.99 79.37,98.26 IC15.4 | 80.64,96.99 84.45,96.99 85.72,98.26 IC15.7 86.99,98.26 93.34,98.26 IC16.1 94.61,98.26 95.88,96.99 109.85,96.99 111.12,98.26 IC16.8 112.39,98.26 118.74,98.26 IC17.1 | 80.64,96.99 67.94,96.99 66.67,98.26 IC14.7 | IC6.8 150.49,126.2 156.84,126.2 IC7.1 158.11,126.2 159.38,124.93 173.35,124.93 174.62,126.2 IC7.8 175.89,127.47 177.8,127.47 180.97,130.65 185.41,130.65 186.69,131.92 IC8.1 | IC4.7 102.23,126.2 103.5,126.2 IC4.8 104.77,127.47 v106.68,127.47 | 135.25,116.04 136.52,114.77 IC10.2 | 135.25,116.04 126.36,116.04 125.09,114.77 IC9.7 | 135.25,116.04 147.95,116.04 149.22,114.77 IC10.7 | IC18.7 160.65,98.89 186.69,98.89 IC12.7 | J6.2 172.08,43.02 170.81,43.02 D34L.17 | 184.78,8.09 185.41,7.46 186.69,7.46 IC37.10 | 184.78,8.09 183.51,9.36 INTENB.8 | 184.78,8.09 177.16,8.09 175.89,9.36 INTENB.5 | INTENB.9 183.51,17.62 186.69,17.62 IC37.6 | C36L.39 183.51,70.95 186.69,70.95 FIELD.8 189.22,70.95 194.31,70.95 FIELD.9 | IC30.10 186.69,37.94 183.51,37.94 C36L.13 | IC30.6 186.69,48.09 183.51,48.09 C36L.21 | IC30.4 186.69,53.18 183.51,53.18 C36L.25 | v86.36,79.21 88.9,81.75 89.53,81.75 90.8,83.02 IC21.8
INT_RQ\  (via drill 0.61)
  Top 0.254: IC40.6 140.33,8.09 141.6,9.36 141.6,13.17 140.33,14.44 IC40.3 139.06,15.71 137.79,16.98 137.79,40.48 137.16,41.11 137.16,59.52 v138.43,60.8 | v166.37,62.06 166.37,60.16 167.63,58.89 D34L.30
  Bottom 0.254: IC40.6 140.97,7.46 143.5,4.92 146.05,4.92 IC40.8 | v166.37,62.06 165.09,60.8 v138.43,60.8
IOS\  (via drill 0.61)
  Top 0.254: v145.41,90 148.59,93.18 v148.59,102.07 | v154.3,102.07 156.21,100.16 v156.21,92.54 | v163.83,92.54 166.37,92.54 166.37,74.13 168.91,71.59 168.91,57.62 167.63,56.35 D34L.28
  Bottom 0.254: v145.41,90 144.78,90.64 126.36,90.64 124.45,88.73 111.76,88.73 109.85,90.64 IC22.10 | v154.3,102.07 v148.59,102.07 | v163.83,92.54 v156.21,92.54
MYDEV\
  Top 0.254: IC32.4 99.06,39.2 97.79,40.48 97.79,48.09 99.06,49.37 IC29.4 99.06,51.91 100.33,53.18 100.33,60.8 99.06,62.06 IC25.4
  Bottom 0.254: IC32.4 99.69,37.3 104.14,32.86 108.58,32.86 PAD1.1
N$1
  Top 0.254: IC36.9 109.22,29.05 109.22,29.68 PAD8.1
N$2
  Bottom 0.254: IC10.8 150.49,122.39 151.76,123.66 165.73,123.66 167,122.39 IC11.11
N$3  (via drill 0.61)
  Top 0.254: v122.55,41.74 122.55,14.44 123.82,13.17 DMA0-3.5
  Bottom 0.254: v122.55,41.74 129.53,41.74 130.81,43.02 DMA4-7.12
N$4  (via drill 0.61)
  Top 0.254: SW1.1 10.79,113.5 12.06,113.5 SW1.2 13.33,113.5 14.6,113.5 SW1.3 15.87,113.5 17.14,113.5 SW1.4 18.41,113.5 19.68,113.5 SW1.5 | SW1.6 23.49,113.5 24.76,113.5 SW1.7 26.03,113.5 26.67,113.5 | 26.67,113.5 27.3,113.5 SW1.8 | v27.94,81.11 27.3,81.75 27.3,89.37 26.67,90 26.67,113.5
  Bottom 0.254: SW1.6 22.22,113.5 20.95,113.5 SW1.5 | v27.94,81.11 85.09,81.11 85.09,84.92 84.45,85.56 83.18,85.56 81.91,84.29 IC21.4
N$5
  Top 0.254: IC36.15 93.98,29.05 93.98,29.68 PAD2.1
N$6
  Top 0.254: IC36.14 96.52,29.05 96.52,29.68 PAD3.1
N$7
  Top 0.254: IC36.13 99.06,29.05 99.06,29.68 PAD4.1
N$8
  Top 0.254: IC36.12 101.59,29.05 101.59,29.68 PAD5.1
N$9
  Top 0.254: IC36.11 104.14,29.05 104.14,29.68 PAD6.1
N$10
  Top 0.254: IC36.10 106.68,29.05 106.68,29.68 PAD7.1
N$11  (via drill 0.61)
  Top 0.254: v109.22,35.4 107.95,34.12 107.95,22.7 106.68,21.43 IC36.7
  Bottom 0.254: v109.22,35.4 111.76,35.4 113.03,34.12 113.03,30.95 111.76,30.95 PAD9.1
N$12  (via drill 0.61)
  Top 0.254: DAR4-7.14 147.95,48.73 149.22,50 149.22,76.67 147.95,77.94 DAR8-11.14 | v168.91,104.61 v168.91,84.29
  Bottom 0.254: v168.91,104.61 161.92,104.61 160.65,105.88 IC18.8 | v168.91,84.29 164.46,79.84 149.86,79.84 148.59,78.57 DAR8-11.14
N$13
  Top 0.254: DMA4-7.5 125.09,43.65 127.63,46.19 127.63,60.16 130.17,62.7 130.17,71.59 131.44,72.86 DMA8-11.12
N$14  (via drill 0.61)
  Top 0.254: v83.81,103.97 83.81,100.16 IC15.6
  Bottom 0.254: 64.13,108.42 47.62,108.42 46.35,107.15 IC13.8 | 64.13,108.42 65.4,107.15 IC14.8 | v83.81,103.97 82.55,105.24 82.55,108.42 64.13,108.42
N$15
  Bottom 0.254: IC2.5 46.35,127.47 47.62,128.74 109.85,128.74 111.12,127.47 IC5.2
N$16  (via drill 0.61)
  Top 0.254: v136.52,26.51 137.16,25.87 137.16,16.35 133.34,12.54 DMA0-3.12 | v145.41,30.32 145.41,33.49 144.78,34.12 144.78,51.27 142.24,53.81 142.24,70.95 v142.87,71.59
  Bottom 0.254: v136.52,26.51 140.33,30.32 v145.41,30.32 | v142.87,71.59 140.97,73.49 DAR8-11.5
N$17  (via drill 0.61)
  Top 0.254: SW2.1 36.19,113.5 37.46,113.5 SW2.2 38.73,113.5 40,113.5 SW2.3 41.27,113.5 42.54,113.5 SW2.4 43.81,113.5 45.08,113.5 SW2.5 | SW2.8 52.7,113.5 51.43,113.5 SW2.7 50.16,113.5 48.89,113.5 SW2.6 48.25,112.86 48.25,102.07 49.52,100.8 49.52,84.92 v51.43,83.02
  Bottom 0.254: SW2.6 47.62,113.5 46.35,113.5 SW2.5 | v51.43,83.02 52.7,81.75 81.91,81.75 83.18,83.02 IC21.5
N$19
  Top 0.254: SW3.1 61.59,113.5 62.86,113.5 SW3.2 64.13,113.5 65.4,113.5 SW3.3 66.67,113.5 67.94,113.5 SW3.4 69.21,113.5 70.48,113.5 SW3.5 71.75,113.5 73.02,113.5 SW3.6 74.29,113.5 75.56,113.5 SW3.7 | IC21.6 86.36,84.92 85.09,86.19 85.09,107.78 79.37,113.5 SW3.8
  Bottom 0.254: SW3.8 78.1,113.5 76.83,113.5 SW3.7
N$20
  Top 0.254: IC21.7 88.9,84.92 90.17,86.19 90.17,111.59 88.9,112.86 SW4.2 | SW4.1 86.99,113.5 88.26,113.5 SW4.2 | SW4.2 89.53,113.5 90.8,113.5 SW4.3 92.07,113.5 93.34,113.5 SW4.4 94.61,113.5 95.88,113.5 SW4.5 97.15,113.5 98.42,113.5 SW4.6 | SW4.8 103.5,113.5 102.23,113.5 SW4.7
  Bottom 0.254: SW4.7 100.96,113.5 99.69,113.5 SW4.6
N$21  (via drill 0.61)
  Top 0.254: v83.18,114.77 83.18,136.36 67.94,136.36 67.31,135.72 67.31,131.92 71.12,128.11 IC3.5 | v113.03,112.23 113.03,115.4 115.56,117.94 115.56,124.29 116.84,125.56 IC5.4
  Bottom 0.254: v83.18,114.77 85.72,112.23 v113.03,112.23
N$22  (via drill 0.61)
  Top 0.254: 133.98,46.19 133.98,19.52 132.71,18.25 DMA0-3.14 | 133.98,46.19 132.71,47.46 DMA4-7.14 | 133.98,76.67 132.71,77.94 DMA8-11.14 | 133.98,76.67 133.98,46.19 | v157.47,93.81 157.47,97.62 IC18.6 | v135.25,93.81 133.98,92.54 133.98,76.67
  Bottom 0.254: v157.47,93.81 v135.25,93.81
N$23
  Bottom 0.254: IC1.5 20.95,126.2 22.22,124.93 107.31,124.93 108.58,126.2 IC5.1
N$24  (via drill 0.61)
  Top 0.254: v97.79,123.66 97.79,124.29 96.52,125.56 IC4.5
  Bottom 0.254: v97.79,123.66 98.42,124.29 116.84,124.29 118.74,126.2 IC5.5
N$25  (via drill 0.61)
  Top 0.254: v141.6,51.91 138.43,51.91 137.79,51.27 137.79,44.92 139.06,43.65 DAR4-7.5 | v143.5,53.81 144.78,55.08 144.78,70.95 146.68,72.86 DAR8-11.12
  Bottom 0.254: v141.6,51.91 v143.5,53.81
N$26
  Top 0.254: IC22.1 99.06,84.92 100.33,86.19 100.33,92.54 105.41,97.62 105.41,103.97 106.68,105.24 IC16.11
N$27  (via drill 0.61)
  Top 0.254: v127,93.18 127,97.62 IC17.4
  Bottom 0.254: v127,93.18 108.58,93.18 107.31,91.91 IC22.11
N$28
  Top 0.254: IC19.1 167.63,95.08 166.37,96.35 166.37,123.02 167.63,124.29 167.63,125.56 IC7.5
N$29
  Top 0.254: RA.2 198.12,119.85 198.12,121.12 RB.1 198.12,122.39 199.38,123.66 199.38,125.56 196.21,128.74 IC8.7
N$30
  Top 0.254: IC12.2 187.32,112.23 187.32,113.5 IC12.1 188.59,114.77 189.86,116.04 189.86,124.93 188.59,126.2 IC8.3
  Bottom 0.254: IC8.3 187.32,127.47 186.05,128.74 185.41,128.74 RL.2
N$31  (via drill 0.61)
  Top 0.254: v152.4,117.94 152.4,107.78 IC18.11 | v146.68,118.58 144.78,120.48 IC10.10
  Bottom 0.254: v152.4,117.94 151.76,118.58 v146.68,118.58
N$32
  Top 0.254: RB.2 187.32,121.75 186.05,123.02 186.05,127.47 187.32,128.74 IC8.2
  Bottom 0.254: 191.77,129.38 194.31,126.83 IC8.6 | 191.77,129.38 189.22,129.38 IC8.2 | 191.77,129.38 193.03,129.38 193.03,133.82 C1.1
N$33
  Top 0.254: IC19.11 175.25,102.7 174.62,103.34 174.62,112.23 173.99,112.86 173.99,128.11 168.27,133.82 IC7.12
N$34
  Top 0.254: IC8.5 196.84,124.29 197.48,124.29 C2.2
N$53
  Bottom 0.254: SW1.16 10.79,121.12 12.06,119.85 15.87,119.85 16.51,120.48 16.51,126.2 17.14,126.2 IC1.4
N$54
  Top 0.254: SW1.15 12.69,123.02 15.23,125.56 IC1.3
N$55
  Bottom 0.254: SW1.14 15.23,123.02 12.69,125.56 IC1.2
N$56
  Top 0.254: IC1.1 10.15,125.56 11.42,124.29 11.42,120.48 12.06,119.85 17.14,119.85 17.14,121.12 SW1.13
N$57
  Bottom 0.254: SW1.11 22.22,122.39 19.05,125.56 19.05,132.55 17.14,132.55 15.87,133.82 IC1.14
N$58
  Top 0.254: SW1.10 25.39,123.02 24.12,124.29 24.12,128.11 18.41,133.82 IC1.13
N$59
  Top 0.254: SW1.9 27.94,123.02 26.67,124.29 26.67,128.11 20.95,133.82 IC1.12
N$60
  Top 0.254: SW1.12 19.68,122.39 16.51,125.56 16.51,129.38 12.69,133.19 IC1.15
N$61
  Top 0.254: SW2.16 35.55,120.48 36.19,119.85 36.19,119.21 41.9,119.21 41.9,124.29 43.17,125.56 IC2.4
N$62
  Top 0.254: SW2.15 38.09,123.02 40.63,125.56 IC2.3
N$63
  Top 0.254: SW2.14 40,121.12 38.73,119.85 36.82,119.85 36.82,124.29 38.09,125.56 IC2.2
N$64
  Top 0.254: IC2.1 36.19,127.47 37.46,128.74 44.45,128.74 44.45,124.29 43.17,123.02 SW2.13
N$65
  Top 0.254: SW2.11 48.25,123.02 46.98,124.29 46.98,128.11 41.27,133.82 IC2.14
N$66
  Top 0.254: SW2.10 50.79,123.02 49.52,124.29 49.52,128.11 43.81,133.82 IC2.13
N$67
  Top 0.254: SW2.9 53.34,123.02 52.06,124.29 52.06,128.11 46.35,133.82 IC2.12
N$68
  Top 0.254: SW3.16 60.95,123.02 62.22,124.29 62.22,128.11 62.86,128.74 67.94,128.74 67.94,127.47 IC3.4
N$69
  Top 0.254: SW3.15 63.49,123.02 66.04,125.56 IC3.3
N$70
  Top 0.254: SW3.14 65.4,121.12 64.13,119.85 62.22,119.85 62.22,123.02 63.49,124.29 63.49,125.56 IC3.2
N$71
  Top 0.254: IC3.1 60.95,125.56 59.68,124.29 59.68,120.48 60.95,119.21 67.94,119.21 67.94,121.12 SW3.13
N$72
  Top 0.254: SW3.11 73.02,122.39 69.84,125.56 69.84,128.11 66.04,131.92 66.04,133.19 IC3.14
N$73
  Top 0.254: SW3.10 75.56,122.39 72.39,125.56 72.39,129.38 68.58,133.19 IC3.13
N$74
  Top 0.254: SW3.9 78.1,122.39 74.93,125.56 74.93,129.38 71.12,133.19 IC3.12
N$75
  Top 0.254: SW4.16 86.36,123.02 87.62,124.29 87.62,128.11 88.26,128.74 93.98,128.74 93.98,128.11 IC4.4
N$76
  Top 0.254: SW4.15 88.9,123.02 91.44,125.56 IC4.3
N$77
  Top 0.254: SW4.14 90.8,121.12 89.53,119.85 87.62,119.85 87.62,123.02 88.9,124.29 88.9,125.56 IC4.2
N$78
  Top 0.254: IC4.1 86.36,128.11 87.62,129.38 95.25,129.38 95.25,124.29 93.98,123.02 SW4.13
N$79
  Top 0.254: SW4.11 99.69,121.12 100.96,119.85 102.87,119.85 102.87,123.02 100.33,125.56 100.33,128.11 95.25,133.19 95.25,135.72 94.61,136.36 91.44,136.36 91.44,135.72 IC4.14
N$80
  Top 0.254: SW4.10 100.96,122.39 97.79,125.56 97.79,129.38 93.98,133.19 IC4.13
N$81
  Top 0.254: SW4.9 104.14,123.02 102.87,124.29 102.87,128.11 97.15,133.82 IC4.12
N$82
  Top 0.254: IC4.15 88.9,133.19 87.62,131.92 87.62,130.65 85.09,128.11 85.09,120.48 86.36,119.21 95.88,119.21 95.88,121.12 SW4.12
N$83
  Top 0.254: SW3.12 71.12,120.48 67.94,117.31 59.05,117.31 59.05,128.74 63.49,133.19 IC3.15
N$84
  Top 0.254: SW2.12 45.08,121.12 42.54,118.58 34.28,118.58 34.28,129.38 38.09,133.19 IC2.15
PBIT  (via drill 0.61)
  Top 0.254: v62.22,88.73 62.22,96.35 63.49,97.62 IC14.6 | v3.81,25.23 v3.81,74.77 | v77.47,14.44 78.1,15.08 78.1,16.98 IC35.11
  Bottom 0.254: v62.22,88.73 60.32,86.83 24.76,86.83 24.12,87.46 21.59,87.46 16.51,82.38 11.42,82.38 v3.81,74.77 | v3.81,25.23 14.6,14.44 v77.47,14.44
PCA
  Top 0.254: IC12.3 188.59,108.42 189.86,107.15 189.86,14.44 188.59,13.17 IC37.8
  Bottom 0.254: IC40.5 140.97,10 142.24,11.27 163.83,11.27 165.73,13.17 187.32,13.17 IC37.8
PER  (via drill 0.61)
  Top 0.254: v123.19,130.65 123.19,124.29 121.92,123.02 IC9.9 | v153.66,131.92 153.66,119.21 154.94,117.94 154.94,114.13 161.28,107.78 161.28,90 161.92,89.37 v161.92,77.3 | v180.34,76.67 185.41,71.59 v185.41,60.8
  Bottom 0.254: v123.19,130.65 124.45,131.92 v153.66,131.92 | v161.92,77.3 162.56,76.67 v180.34,76.67 | v185.41,60.8 187.32,58.89 IC30.2
PER\  (via drill 0.61)
  Top 0.254: v136.52,109.69 132.08,114.13 v132.08,121.12
  Bottom 0.254: v136.52,109.69 183.51,109.69 186.69,106.52 IC12.4 | v132.08,121.12 125.09,121.12 IC9.8
PIE  (via drill 0.61)
  Top 0.254: IC40.4 139.06,11.9 137.79,10.63 137.79,4.28 139.06,3.01 167,3.01 167,9.36 INTENB.2 | v197.48,13.81 197.48,51.27 196.21,52.54 IC30.17
  Bottom 0.254: v197.48,13.81 197.48,11.27 184.15,11.27 182.88,12.54 170.18,12.54 168.27,10.63 INTENB.2
PROTECT  (via drill 0.61)
  Top 0.254: v121.92,130.01 121.92,128.11 IC5.6
  Bottom 0.254: v121.92,130.01 122.55,129.38 127,129.38 128.27,128.11 130.81,128.11 131.44,128.74 135.25,128.74 136.52,127.47 IC6.3
SETPER\  (via drill 0.61)
  Top 0.254: v44.45,110.32 44.45,103.97 40.63,100.16 IC13.5 | v118.11,112.23 118.11,119.21 119.38,120.48 IC9.10
  Bottom 0.254: v44.45,110.32 46.35,112.23 84.45,112.23 85.72,110.96 116.84,110.96 v118.11,112.23
SETWLS\  (via drill 0.61)
  Top 0.254: v120.65,124.93 120.65,110.32 118.11,110.32 116.84,111.59 116.84,112.86 IC9.4
  Bottom 0.254: v120.65,124.93 121.28,124.29 144.78,124.29 146.68,126.2 IC6.7
SKIP\  (via drill 0.61)
  Top 0.254: IC19.10 177.8,100.16 180.34,97.62 180.34,95.08 IC19.6 | v122.55,91.91 122.55,96.99 121.92,97.62 IC17.2
  Bottom 0.254: 168.27,91.91 166.37,91.91 165.73,91.27 R1.1 164.46,91.27 123.19,91.27 v122.55,91.91 | 168.27,91.91 169.54,93.18 IC19.2 | 168.27,91.91 178.43,91.91 179.7,93.18 IC19.6
START\  (via drill 0.61)
  Top 0.254: DMA0-3.11 131.44,10.63 130.17,11.9 130.17,38.57 131.44,39.84 DMA4-7.11 | 134.62,72.86 v135.25,73.49 | 134.62,72.86 134.62,41.11 v135.25,40.48 | v140.33,97.62 134.62,91.91 134.62,72.86
  Bottom 0.254: v135.25,73.49 134.62,73.49 132.71,71.59 DMA8-11.11 | v135.25,40.48 133.34,40.48 DMA4-7.11 | v140.33,97.62 140.97,96.99 147.95,96.99 149.22,98.26 IC18.3
VCC  (via drill 0.61)
  Top 0.508: IC40.14 146.68,20.79 v146.68,22.7 147.95,23.96 v147.95,26.51 146.68,27.78 146.68,33.49 145.41,34.76 145.41,38.57 146.05,39.2 149.86,39.2 149.86,81.11 147.95,83.02 DAR8-11.16 146.68,84.29 142.24,88.73 | IC38.20 161.28,27.78 165.09,31.59 168.91,31.59 168.91,27.14 168.27,26.51 167,26.51 165.73,25.23 165.73,18.25 INTENB.16 | 142.24,88.73 142.24,102.7 144.78,105.24 IC18.14 144.14,107.15 138.43,112.86 138.43,123.02 137.79,123.66 133.98,123.66 | 133.98,123.66 133.34,124.29 133.34,131.92 132.08,133.19 IC6.16 | 133.98,123.66 134.62,123.02 IC10.14 | IC11.14 159.38,122.39 156.21,125.56 156.21,131.92 157.47,133.19 IC7.16 158.11,135.09 160.02,137 194.94,137 194.94,132.55 IC8.8 196.84,131.92 196.84,131.28 198.12,130.01 C2.1 | IC11.10 170.18,120.48 170.18,117.94 167.63,115.4 IC11.4 167.63,112.86 167.63,102.7 IC19.14 | RL.1 186.05,119.21 187.32,119.21 RA.1 187.96,119.85 189.22,121.12 189.22,123.02 188.59,123.66 IC8.4 | IC12.14 194.94,113.5 193.67,112.23 193.67,90.64 194.94,89.37 FIELD.16 194.94,88.1 193.67,86.83 193.67,80.48 194.31,79.84 197.48,79.84 197.48,62.7 196.21,61.43 IC30.20 194.94,60.16 193.67,58.89 193.67,32.22 194.94,30.95 IC37.20 | v132.71,55.72 132.71,53.81 DMA4-7.16 | J7.2 172.72,41.11 171.44,42.38 171.44,46.19 172.72,47.46 J5.2 172.72,48.73 172.72,50 J4.2 172.72,51.27 172.72,52.54 J3.2 172.72,53.81 v172.72,59.52 | v147.95,56.98 147.95,53.81 DAR4-7.16 | v86.36,130.65 86.36,133.19 IC4.16 | 110.48,132.55 109.22,132.55 109.22,133.19 IC5.14 | 110.48,132.55 113.66,132.55 118.11,128.11 118.11,120.48 117.47,119.85 117.47,117.31 115.56,115.4 115.56,111.59 119.38,107.78 IC17.16
  Top 0.508: 100.33,103.97 100.33,108.42 104.14,112.23 107.95,112.23 107.95,119.21 109.22,120.48 IC9.14 109.22,123.02 110.48,124.29 110.48,132.55 | 100.33,103.97 100.33,93.81 99.06,92.54 IC22.14 | v132.08,87.46 132.08,84.29 DMA8-11.16 | IC41.16 76.2,13.81 76.2,32.86 77.47,34.12 80.64,34.12 80.64,36.03 80.01,36.66 76.83,36.66 76.83,38.57 78.1,39.84 IC35.20 | IC36.16 91.44,29.05 92.07,29.68 92.07,36.03 92.7,36.66 92.7,43.02 91.44,44.29 IC32.16 91.44,46.83 92.7,48.09 92.7,51.91 92.07,52.54 92.07,56.35 91.44,56.98 IC29.16 91.44,59.52 91.44,60.8 92.7,62.06 92.7,68.41 91.44,69.68 IC25.16 | v104.14,23.33 104.14,21.43 IC36.6 | v25.39,44.29 24.12,43.02 IC34.20 | IC39.32 27.94,23.96 28.57,24.6 28.57,28.41 29.21,29.05 29.21,31.59 27.94,32.86 27.94,44.29 IC33.32 27.94,46.83 27.94,49.37 29.21,50.63 29.21,54.45 28.57,55.08 28.57,66.51 27.94,67.14 IC27.32 27.94,69.68 28.57,70.32 28.57,74.13 29.21,74.77 29.21,87.46 27.94,88.73 27.94,90 IC23.32 27.94,92.54 v27.94,95.08 | IC15.14 71.12,105.24 76.2,100.16 IC15.3 76.2,97.62 76.2,95.08 73.66,92.54 IC21.16 73.66,90 73.66,88.73 74.93,87.46 74.93,82.38 78.1,79.21 78.1,69.05 IC28.20 | IC3.16 60.95,133.19 58.41,130.65 58.41,115.4 50.79,107.78 IC14.14 50.79,105.24 v50.79,102.7 | IC26.20 22.22,74.13 20.95,75.4 20.95,94.45 21.59,95.08 24.76,95.08 24.76,102.07 23.49,103.34 IC20.20 | v55.88,102.07 55.88,100.16 IC14.3 | IC2.16 35.55,133.19 30.48,128.11 30.48,107.78 IC13.14 | 100.33,103.97 v99.06,103.97 | 142.24,88.73 v141.6,88.1
  Bottom 0.508: v146.68,22.7 133.34,22.7 DMA0-3.16 | v147.95,26.51 156.84,26.51 158.11,27.78 158.75,27.78 IC38.20 | IC6.16 132.71,133.82 133.98,132.55 152.4,132.55 153.66,133.82 156.84,133.82 IC7.16 | IC24.20 161.28,88.73 163.19,86.83 186.05,86.83 186.69,87.46 193.03,87.46 194.31,88.73 FIELD.16 | R1.2 165.73,101.43 167,101.43 IC19.14 | IC12.14 194.31,114.13 189.22,119.21 188.59,119.21 RA.1 | C2.1 198.12,128.74 198.12,125.56 190.5,125.56 189.22,124.29 IC8.4 | IC11.10 170.81,121.12 172.72,119.21 184.78,119.21 RL.1 | v132.71,55.72 133.34,55.08 144.14,55.08 146.05,53.18 DAR4-7.16 | 162.56,59.52 161.28,58.26 IC31.20 | 162.56,59.52 v172.72,59.52 177.16,59.52 179.7,62.06 193.03,62.06 194.31,60.8 IC30.20 | v147.95,56.98 150.49,59.52 162.56,59.52 | v86.36,130.65 86.99,131.28 106.04,131.28 108.58,133.82 IC5.14 | IC22.14 98.42,90.64 93.98,90.64 93.98,87.46 94.61,86.83 131.44,86.83 v132.08,87.46 140.97,87.46 v141.6,88.1 | IC28.20 80.01,68.41 81.91,70.32 90.8,70.32 IC25.16 | v104.14,23.33 101.59,25.87 93.34,25.87 92.07,27.14 IC36.16 | IC35.20 80.01,40.48 81.28,41.74 87.62,41.74 90.8,44.92 IC32.16 | v25.39,44.29 26.03,44.92 27.3,44.92 IC33.32 | 92.07,104.61 89.53,102.07 75.56,102.07 71.75,105.88 IC15.14 70.48,105.88 67.94,103.34 57.14,103.34 v55.88,102.07 50.79,102.07 | 92.07,104.61 93.34,105.88 IC16.16 | IC1.16 10.79,135.09 13.33,137.63 34.92,137.63 35.55,137 35.55,135.72 IC2.16 | 32.38,96.99 33.65,96.99 34.92,98.26 IC13.3 | 32.38,96.99 31.75,97.62 31.75,102.07 | 31.75,102.07 31.75,105.24 30.48,105.24 IC13.14 29.84,105.88 26.03,105.88 24.12,103.97 IC20.20 | 50.79,102.07 31.75,102.07
  Bottom 0.508: 50.79,102.07 v50.79,102.7 | v27.94,95.08 29.84,96.99 32.38,96.99 | v99.06,103.97 98.42,104.61 92.07,104.61
WE\  (via drill 0.61)
  Top 0.254: IC39.29 35.55,23.96 36.82,25.23 36.82,43.02 35.55,44.29 IC33.29 35.55,46.83 36.82,48.09 36.82,65.88 35.55,67.14 IC27.29 35.55,69.68 36.82,70.95 36.82,88.73 35.55,90 IC23.29 | v130.17,126.2 129.53,126.83 129.53,131.92 124.45,137 105.41,137 105.41,120.48 100.33,115.4 100.33,112.86 95.25,107.78 95.25,105.24 v92.7,102.7
  Bottom 0.254: v130.17,126.2 131.44,124.93 140.33,124.93 141.6,126.2 IC6.5 | v92.7,102.7 90.8,100.8 60.32,100.8 59.68,100.16 59.68,96.35 40.63,96.35 36.19,91.91 IC23.29
WLS  (via drill 0.61)
  Top 0.254: v85.72,117.31 83.81,119.21 83.81,137.63 195.58,137.63 195.58,135.72 201.29,130.01 201.29,11.27 186.69,11.27 186.05,11.9 186.05,20.79 187.32,22.06 IC37.4
  Bottom 0.254: v85.72,117.31 86.36,116.67 116.84,116.67 118.74,114.77 IC9.5
WLS\  (via drill 0.61)
  Top 0.254: v177.16,128.74 177.16,114.77 187.32,104.61 IC12.5 | v126.36,130.65 v126.36,117.31
  Bottom 0.254: v177.16,128.74 175.25,130.65 v126.36,130.65 | v126.36,117.31 125.09,116.04 123.82,116.04 122.55,114.77 IC9.6
WRITING  (via drill 0.61)
  Top 0.254: v153.66,117.94 153.03,118.58 153.03,128.74 136.52,128.74 135.25,127.47 IC6.2 | v146.05,117.31 144.78,116.04 144.78,115.4 IC10.5 | v49.52,10.63 48.25,11.9 48.25,21.43 IC39.24 48.25,23.96 48.89,24.6 48.89,28.41 49.52,29.05 49.52,31.59 48.25,32.86 48.25,44.29 IC33.24 48.89,46.19 48.89,50 49.52,50.63 49.52,54.45 48.89,55.08 48.89,66.51 48.25,67.14 IC27.24 48.25,69.68 48.89,70.32 48.89,74.13 49.52,74.77 49.52,83.65 48.25,84.92 48.25,90 IC23.24 48.25,92.54 46.98,93.81 v46.98,116.04 | v106.68,119.85 106.04,119.21 v106.04,115.4
  Bottom 0.254: v153.66,117.94 152.4,116.67 146.68,116.67 v146.05,117.31 144.14,119.21 107.31,119.21 v106.68,119.85 | IC41.13 83.18,11.9 81.91,11.9 IC41.14 80.64,11.9 79.37,10.63 v49.52,10.63 | v106.04,115.4 105.41,116.04 v46.98,116.04

## Text on the board
Bottom: RF08 | vrs